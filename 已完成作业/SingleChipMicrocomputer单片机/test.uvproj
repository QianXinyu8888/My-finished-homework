# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C52 ISSI
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(40000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 789.c
